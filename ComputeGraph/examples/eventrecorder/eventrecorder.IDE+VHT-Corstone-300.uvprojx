# Keil uVision project eventrecorder.IDE+VHT-Corstone-300.uvprojx, settings and files
target IDE+VHT-Corstone-300 (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: eventrecorder.IDE+VHT-Corstone-300.axf
  c flags: Optim=5 v6Lang=5 v6LangP=3 wLevel=3
  c define: NDEBUG NDEBUG AVH
  c misc: -Wsign-compare -Wdouble-promotion  -ffast-math -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-reserved-identifier  -ffast-math
  c include: generated;.
  asm define: AVH
  asm include: generated;.
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler --info=summarysizes --info=sizes --info=totals --info=unused --info=veneers
  group App
    ./: main.cpp
    ./generated/: scheduler.cpp
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.3, CMSIS:DSP:Compute Graph 1.14.3, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
